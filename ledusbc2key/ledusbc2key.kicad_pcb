# Repository alexoltl/pcb-design

File README.md:

# pcb-design
personal pcb learning. if i have time, i'll add resources to help you

i am following [ai03's guide to pcbs](https://wiki.ai03.com/books/pcb-design/chapter/pcb-designer-guide). i'll see how i'm do with that for the next while.

## components required

all of these needs to be surface mount hand soldierable. i'll try to find them from the same company (mouser or jaycar) but amazon is pretty good. all of these don't include shipping.

| Component Name | Place(s) to purchase from |Price/part (lowest amount available)|
|----------------|---------------------------|------------------------------------|
| ATMEGA32u2-AR  | [mouser](https://nz.mouser.com/ProductDetail/Microchip-Technology-Atmel/ATMEGA32U2-AU?qs=rBGENRD8NwKYx79eccv8UA%3D%3D), theres some wait | NZ$6.43 for one |
| Kailh Hotswap Sockets | [aliexpress](https://www.aliexpress.com/item/32959301642.html) and ~[amazon](https://www.amazon.com/Hot-swappable-Socket-CPG151101S11-Mechanical-Keyboard/dp/B07K8CCMQZ) can't ship to nz :(~ | aliexpress: NZ$0.469 each for 30pcs, amazon: NZ$0.248 each for 50pcs |
| WS2812B | [amazon](https://www.amazon.com/BTF-LIGHTING-Flexible-Individually-Addressable-Non-waterproof/dp/B01CDTEJBG) | $1.798 for 1m |
| TSX-3225 | [mouser](https://nz.mouser.com/c/passive-components/frequency-control-timing-devices/crystals/?m=Epson&series=TSX-3225) | specific part not found using footprint, but varies from NZ$0.709 - 1.400 each |
| Resistors | [jaycar](https://www.jaycar.co.nz/components-electromechanical/resistors/metal-film/c/2AA?sort=popularity-desc&q), metal film and carbon film are available | NZ$1 each for most, if not usually cheaper |
| 1N4148W-TP (not needed for 2k or 3k) | [mouser](https://nz.mouser.com/ProductDetail/Micro-Commercial-Components-MCC/1N4148W-TP?qs=KFo7JewZbUH7wCMabJ4EeQ%3D%3D), **has not been checked yet, just has the same name as the footprint i used** | NZ$0.321 for one |
| TL3342F160QG | [mouser](https://nz.mouser.com/ProductDetail/E-Switch/TL3342F160QG?qs=6C6BR4UgC3N80rVVEktZJA%3D%3D) same as above | NZ$1.03 for one |
| Molex 216990-0003 | [mouser](https://nz.mouser.com/ProductDetail/Molex/216990-0003?qs=DRkmTr78QASn0GILUGAYCA%3D%3D) same as above | NZ$1.43 for one |

# Resistors and diodes used
## ledusbc2key
## numpad

# PCB statistics report
Auto generated by KiCad

__Board__
- Width: 43.8150 mm
- Height: 54.2925 mm
- Area: 2273.5889 sq. mm

__Pads__
- Through hole: 4
- SMD: 98
- Connector: 0
- NPTH: 16

__Vias__
- Through vias: 17
- Blind/buried: 0
- Micro vias: 0

__Components__
|        | Front Side | Back Side | Total |
|--------|------------|-----------|-------|
|THT:    |         0  |        0  |    0  |
|SMD:    |         2  |       22  |   24  |
|Total:  |         2  |       22  |   24  |
|        |            |           |       |

__Drill holes__
| Count | Shape |    X Size |    Y Size | Plated | Via/Pad | Start Layer | Stop Layer |
|-------|-------|-----------|-----------|--------|---------|-------------|------------|
|    17 | Round | 0.4000 mm | 0.4000 mm |    PTH |     Via |        F.Cu |       B.Cu |
|     4 | Round | 1.7500 mm | 1.7500 mm |   NPTH |     Pad |        F.Cu |       B.Cu |
|     4 | Round | 3.0000 mm | 3.0000 mm |   NPTH |     Pad |        F.Cu |       B.Cu |
|     4 | Round | 2.1000 mm | 2.1000 mm |   NPTH |     Pad |        F.Cu |       B.Cu |
|     2 | Round | 3.9878 mm | 3.9878 mm |   NPTH |     Pad |        F.Cu |       B.Cu |
|     2 | Round | 0.6500 mm | 0.6500 mm |   NPTH |     Pad |        F.Cu |       B.Cu |
|     2 |  Slot | 0.6000 mm | 1.2000 mm |    PTH |     Pad |        F.Cu |       B.Cu |
|     2 |  Slot | 0.6000 mm | 1.7000 mm |    PTH |     Pad |        F.Cu |       B.Cu |

## KiCad design ledusbc2key/ledusbc2key.kicad_pcb

Parts:
C1: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 14pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5, C7, C8: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
F1: Polyfuse_Small; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R1, R6: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_Push; SKQGADE010
SW2, SW3: MX_SW_HS; SW_MX_HS_1u
U1: ATmega32U2-A; TQFP-32_7x7mm_P0.8mm
U2: PRTR5V0U2X; SOT143B
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-HandSoldering
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, C8.1, D1.1 (VDD), D2.1 (VDD), F1.1, R1.1, U1.4 (VCC), U1.31 (UVCC), U1.32 (AVCC)
COL0: SW2.2, U1.26 (PC4)
COL1: SW3.2, U1.25 (PC5)
D+: R2.1, U2.2 (IO1), USB1.6 (DP1), USB1.8 (DP2)
D-: R3.2, U2.3 (IO2), USB1.5 (DN2), USB1.7 (DN1)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, D1.3 (VSS), D2.3 (VSS), R4.1, R5.1, R6.2, SW1.1, SW2.1, SW3.1, U1.3 (GND), U1.28 (UGND), U2.1 (GND), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHIELD), Y1.2, Y1.4
LED: D1.4 (DIN), U1.17 (PB3)
unnamed: C1.1, U1.27 (UCAP)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: R1.2, SW1.2, U1.24 (PC1/~RESET)
unnamed: R2.2, U1.29 (D+)
unnamed: R3.1, U1.30 (D-)
unnamed: R4.2, USB1.4 (CC1)
unnamed: R5.2, USB1.10 (CC2)
unnamed: R6.1, U1.13 (~HWB/PD7)
VCC: F1.2, U2.4 (VCC), USB1.2 (VBUS), USB1.11 (VBUS)
XTAL1: C2.2, U1.1 (XTAL1), Y1.1
XTAL2: C3.2, U1.2 (PC0/XTAL2), Y1.3

Board: 2 copper layers, 38.1 x 52.2 mm, 24 parts (24 on the bottom side), 18 nets.

## KiCad design numpad/numpad.kicad_pcb

Parts:
C1: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 14pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C4, C5: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17: D_Small; D_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1: Polyfuse_Small; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R1, R6: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3: 22; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
S1, S2, S3: MX_stab; STAB_MX_2u
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17: MX_SW_HS; SW_MX_HS_1u
SW18: SW_Push; SKQGADE010
U1: ATmega32U2-A; TQFP-32_7x7mm_P0.8mm
U2: PRTR5V0U2X; SOT143B
USB1: HRO-TYPE-C-31-M-12; HRO-TYPE-C-31-M-12-HandSoldering
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C4.1, C5.1, C6.1, F1.1, R1.1, U1.4 (VCC), U1.31 (UVCC), U1.32 (AVCC)
COL0: SW1.2, SW5.2, SW9.2, SW12.2, SW16.2, U1.9 (PD3)
COL1: SW2.2, SW6.2, SW10.2, SW13.2, U1.10 (PD4)
COL2: SW3.2, SW7.2, SW11.2, SW14.2, SW17.2, U1.7 (PD1)
COL3: SW4.2, SW8.2, SW15.2, U1.25 (PC5)
D+: R2.1, U2.2 (IO1), USB1.6 (DP1), USB1.8 (DP2)
D-: R3.2, U2.3 (IO2), USB1.5 (DN2), USB1.7 (DN1)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, R4.1, R5.1, R6.2, SW18.1, U1.3 (GND), U1.28 (UGND), U2.1 (GND), USB1.1 (GND), USB1.12 (GND), USB1.13 (SHIELD), Y1.2, Y1.4
unnamed: C1.1, U1.27 (UCAP)
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: R1.2, SW18.2, U1.24 (PC1/~RESET)
unnamed: R2.2, U1.29 (D+)
unnamed: R3.1, U1.30 (D-)
unnamed: R4.2, USB1.4 (CC1)
unnamed: R5.2, USB1.10 (CC2)
unnamed: R6.1, U1.13 (~HWB/PD7)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), U1.12 (PD6)
ROW1: D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), U1.11 (PD5)
ROW2: D9.1 (K), D10.1 (K), D11.1 (K), U1.8 (PD2)
ROW3: D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), U1.26 (PC4)
ROW4: D16.1 (K), D17.1 (K), U1.22 (PC7)
VCC: F1.2, U2.4 (VCC), USB1.2 (VBUS), USB1.11 (VBUS)
XTAL1: C2.2, U1.1 (XTAL1), Y1.1
XTAL2: C3.2, U1.2 (PC0/XTAL2), Y1.3

Board: 2 copper layers, 76.2 x 107.3 mm, 55 parts (55 on the bottom side), 40 nets.

## KiCad design initial2key.kicad_pcb

Parts:
C1, C2: 22pF; C_0805_2012Metric
C3: 1uF; C_0805_2012Metric
C4, C5, C6, C7: 0.1uF; C_0805_2012Metric
D1, D2: D_Small; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
MX1, MX2: MX-NoLED; MX-1U
R1, R4: 10k; R_0805_2012Metric
R2, R3: 22; R_0805_2012Metric
SW1: SW_Push; SKQG-1155865
U1: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
USB1: Molex-0548190589
Y1: Crystal_GND24_Small; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C4.1, C5.1, C6.1, C7.1, F1.1, R1.1, U1.2 (UVCC), U1.7 (VBUS), U1.14 (VCC), U1.24 (AVCC), U1.34 (VCC), U1.44 (AVCC)
COL0: MX1.1 (COL), U1.9 (PB1)
COL1: MX2.1 (COL), U1.10 (PB2)
D+: R2.2, USB1.3
D-: R3.2, USB1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, R4.1, SW1.1, U1.5 (UGND), U1.15 (GND), U1.23 (GND), U1.35 (GND), U1.43 (GND), USB1.1, Y1.2, Y1.4
unnamed: C1.1, U1.17 (XTAL1), Y1.1
unnamed: C2.1, U1.16 (XTAL2), Y1.3
unnamed: C3.1, U1.6 (UCAP)
unnamed: D1.2 (A), MX1.2 (ROW)
unnamed: D2.2 (A), MX2.2 (ROW)
unnamed: R1.2, SW1.2, U1.13 (~RESET)
unnamed: R2.1, U1.4 (D+)
unnamed: R3.1, U1.3 (D-)
unnamed: R4.2, U1.33 (~HWB~/PE2)
ROW0: D1.1 (K), D2.1 (K), U1.11 (PB3)
VCC: F1.2, USB1.5

Board: 2 copper layers, 44.5 x 50.0 mm, 20 parts (18 on the bottom side), 17 nets.

## Commit log

2022-09-06 add submodules
2022-09-06 more setup
2022-09-07 please update this time
2022-09-07 using ai03's tutorial now
2022-09-07 2x2 init
2022-09-07 didn't do much today
2022-09-10 did so much today, basically finished the entire routing
2022-09-10 2key
2022-09-10 initial2key folder added
2022-09-11 schem work
2022-09-11 starting pcb file
2022-09-11 more schem and starting pcb
2022-09-11 did a bit today
2022-09-13 finished 2k
2022-09-13 changed location of pcb mountings
2022-09-13 readme
2022-09-13 more details
2022-09-13 fixed and added more details
2022-09-13 fixed again
2022-09-13 fixed spacing
2022-09-13 bolding
2022-09-13 small tests
2022-09-13 components sheet
2022-09-13 components sheet fixed
2022-09-13 add more to the components
2022-09-13 added more
2022-09-13 capitalization
2022-09-14 numpad schem finished for now
2022-09-14 finished keypad, needs cleaning up
2022-09-16 finished numpad pcb
2022-09-16 swapped to new library for ledusbc
2022-09-17 did a bit of work 3d modelling today
2022-09-17 components table updated
2022-10-15 work
